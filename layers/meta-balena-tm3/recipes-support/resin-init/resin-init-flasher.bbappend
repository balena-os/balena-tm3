BOOTLOADER_FLASH_DEVICE = "mmcblk2"
BOOTLOADER_IMAGE = "u-boot-sunxi-with-spl.bin"
BOOTLOADER_BLOCK_SIZE_OFFSET = "1024"
BOOTLOADER_SKIP_OUTPUT_BLOCKS = "8"

INTERNAL_DEVICE_KERNEL = "mmcblk2"
